# Keil uVision project rx.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o CanStm32.bin Output\Project.axf
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\User;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\User\USB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../User/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB-User
    ../User/USB/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../User/: usbio.c
  group User Source
    ../User/: main.c stm32f10x_it.c
    ../User/dsp/: dsp.c
  group Readme
    ../User/: Readme.txt
  group IAP
    ../IAP/: iap.c
  group StmFlash
    ../STMFLASH/: stmflash.c
  group sys
    ../sys/: delay.c sys.c
  group Enc_Dec
    ../Enc_Dec/: encrypto.c
  group hardware
    ../hardware/adc/: adc.c
    ../hardware/key/: key.c
    ../hardware/nrf24l01/: nrf24l01.c rf.c
    ../hardware/oled/: oled.c
    ../hardware/spi/: spi.c
    ../hardware/uart/: uart.c
    ../hardware/pwm/: pwm.c
    ../hardware/timer/: timer.c
software components: CMSIS:CORE 4.3.0
